## src/modules/param_bridge/Kconfig
```kconfig
menuconfig MODULES_PARAM_BRIDGE
	bool "param_bridge"
	default n
	---help---
		Enable support for param_bridge
```
